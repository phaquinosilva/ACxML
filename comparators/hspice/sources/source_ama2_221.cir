** sources and measures for comparator type: ama2_221

*4-bit input A
Va0 a0_in gnd PWL(0n vdd)
Va1 a1_in gnd PWL(0n 0)
Va2 a2_in gnd PWL(0n vdd)
Va3 a3_in gnd PWL(0n vdd)
*4-bit input B
Vb0 b0_in gnd PWL(0n 0 1n 0 1.1n vdd)
Vb1 b1_in gnd PWL(0n vdd)
Vb2 b2_in gnd PWL(0n vdd)
Vb3 b3_in gnd PWL(0n vdd)

*measures
.measure tran tphl trig v(b0) val='0.5*vdd' rise=1 targ v(geq) val='0.5*vdd' fall=1
