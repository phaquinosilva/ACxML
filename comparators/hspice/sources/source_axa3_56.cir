** sources and measures for comparator type: axa3_56

*4-bit input A
Va0 a0_in gnd PWL(0n vdd)
Va1 a1_in gnd PWL(0n 0)
Va2 a2_in gnd PWL(0n 0)
Va3 a3_in gnd PWL(0n 0)
*4-bit input B
Vb0 b0_in gnd PWL(0n 0)
Vb1 b1_in gnd PWL(0n 0)
Vb2 b2_in gnd PWL(0n 0 1n 0 1.1n vdd)
Vb3 b3_in gnd PWL(0n vdd)

*measures
.measure tran tplh trig v(b2) val='0.5*vdd' rise=1 targ v(greater) val='0.5*vdd' rise=1
