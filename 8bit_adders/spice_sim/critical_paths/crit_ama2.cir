** sources file for sum 0

*cin0
Vc0 c0_in gnd PWL(0n 0 1n 0 1.1n vdd)
*8-bit input A
Va0 a0_in gnd PWL(0n vdd)
Va1 a1_in gnd PWL(0n vdd)
Va2 a2_in gnd PWL(0n vdd)
Va3 a3_in gnd PWL(0n vdd)
Va4 a4_in gnd PWL(0n vdd)
Va5 a5_in gnd PWL(0n vdd)
Va6 a6_in gnd PWL(0n vdd)
Va7 a7_in gnd PWL(0n vdd)
*8-bit input B
Vb0 b0_in gnd PWL(0n 0)
Vb1 b1_in gnd PWL(0n 0)
Vb2 b2_in gnd PWL(0n 0)
Vb3 b3_in gnd PWL(0n 0)
Vb4 b4_in gnd PWL(0n 0)
Vb5 b5_in gnd PWL(0n 0)
Vb6 b6_in gnd PWL(0n 0)
Vb7 b7_in gnd PWL(0n 0)

*measures
.measure tran tp_crit trig v(c0) val='0.5*0.7' rise=1 targ v(s7) val='0.5*0.7' fall=1
