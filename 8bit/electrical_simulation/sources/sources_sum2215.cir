** sources file for sum 2215

*8-bit input A
Va0 a0_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Va1 a1_in gnd PWL(0n 0)
Va2 a2_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Va3 a3_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Va4 a4_in gnd PWL(0n 0)
Va5 a5_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Va6 a6_in gnd PWL(0n 0)
Va7 a7_in gnd PWL(0n 0 1n 0 1.1n 0.7)
*8-bit input B
Vb0 b0_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Vb1 b1_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Vb2 b2_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Vb3 b3_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Vb4 b4_in gnd PWL(0n 0)
Vb5 b5_in gnd PWL(0n 0 1n 0 1.1n 0.7)
Vb6 b6_in gnd PWL(0n 0)
Vb7 b7_in gnd PWL(0n 0)

*measures
.measure tran tplh_s0 trig v(tr) val='0.5*0.7' rise=1 targ v(s0_in) val='0.5*0.7' rise=1
.measure tran tphl_s0 trig v(tr) val='0.5*0.7' rise=1 targ v(s0_in) val='0.5*0.7' fall=1
.measure tran tplh_s1 trig v(tr) val='0.5*0.7' rise=1 targ v(s1_in) val='0.5*0.7' rise=1
.measure tran tphl_s1 trig v(tr) val='0.5*0.7' rise=1 targ v(s1_in) val='0.5*0.7' fall=1
.measure tran tplh_s2 trig v(tr) val='0.5*0.7' rise=1 targ v(s2_in) val='0.5*0.7' rise=1
.measure tran tphl_s2 trig v(tr) val='0.5*0.7' rise=1 targ v(s2_in) val='0.5*0.7' fall=1
.measure tran tplh_s3 trig v(tr) val='0.5*0.7' rise=1 targ v(s3_in) val='0.5*0.7' rise=1
.measure tran tphl_s3 trig v(tr) val='0.5*0.7' rise=1 targ v(s3_in) val='0.5*0.7' fall=1
.measure tran tplh_s4 trig v(tr) val='0.5*0.7' rise=1 targ v(s4_in) val='0.5*0.7' rise=1
.measure tran tphl_s4 trig v(tr) val='0.5*0.7' rise=1 targ v(s4_in) val='0.5*0.7' fall=1
.measure tran tplh_s5 trig v(tr) val='0.5*0.7' rise=1 targ v(s5_in) val='0.5*0.7' rise=1
.measure tran tphl_s5 trig v(tr) val='0.5*0.7' rise=1 targ v(s5_in) val='0.5*0.7' fall=1
.measure tran tplh_s6 trig v(tr) val='0.5*0.7' rise=1 targ v(s6_in) val='0.5*0.7' rise=1
.measure tran tphl_s6 trig v(tr) val='0.5*0.7' rise=1 targ v(s6_in) val='0.5*0.7' fall=1
.measure tran tplh_s7 trig v(tr) val='0.5*0.7' rise=1 targ v(s7_in) val='0.5*0.7' rise=1
.measure tran tphl_s7 trig v(tr) val='0.5*0.7' rise=1 targ v(s7_in) val='0.5*0.7' fall=1
